Commit message: Small bug fixes

File: ur_e_description/urdf/ur5e_with_camera.urdf (robot description, URDF)
Before this commit: robot ur5e, 11 links, 10 joints
Links:
- link base: mass None -> 0.1879
- link ee_link: mass None -> 0.1879
- link tool0: mass None -> 0.1879
